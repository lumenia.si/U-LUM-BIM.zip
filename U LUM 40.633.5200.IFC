Properties of the parts of a building model (IFC2X3)

# File
Description: IFC2X3
File name: U LUM 40.633.5200.IFC
Time: 2023-11-03T07:37:50
Written by: SwIFC
Made in: SolidWorks 2017

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 m

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0 m

# IfcBuildingElementProxy: U LUM 40.633.5200
In: Default Storey
SolidWorks Custom Properties - Description: PWR(40W);LUM.FLUX(5200lm)
PSet_Mass_Property - Mass Measure: 9.05245; Area Measure: 0.588991 m2; Volume Measure: 0.00905245 m3
